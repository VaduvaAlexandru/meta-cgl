# Add specific CGL compliance calculation based on the number of existing requirement
# for the CGL 5.0 specification
